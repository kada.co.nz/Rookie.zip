Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-13T12:37:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 13 12:37:43 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{8D1008F4-29A4-4A8E-AC93-3BDA91BCC959}\ifc * Database version: 5507 * Database creation date: Fri Sep 13 12:37:42 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 13 12:37:42 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 13 12:37:42 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Rookie, Furniture_Office-Chairs_Vitra_Rookie:Rookie:383554
In: Level 1
Type - Material: Stainless Steel, Basic dark, 53 soft grey, Sierra grey 19
Type - Dimensions(Type) - NominalDepth: 710 mm; NominalLength: 710 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Office-Chairs_Vitra_Rookie; ConvergoRefNr: 0089-1909-0018-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: Rookie (2018) by Konstantin Grcic is a small, agile and – by office standards – unconventionally simple chair. It provides a high level of immediate comfort with a minimal number of adjustments.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 10/09/2019
Type - Identity Data(Type) - Collection: Rookie; Cost: 0; Description: Rookie is a small, agile and – by office standards – unconventionally simple chair. It provides a high level of immediate comfort with a minimal number of adjustments. 'Rookie is all about flexibility and change. Its design aesthetic symbolises that magic moment when something new is beginning, but everything is still up in the air. Equally suited as a single desk chair for students or in larger numbers across a wide range of corporate workplaces, Rookie is designed for environments that encourage the creation and exchange of ideas.' Both the seat and backrest of Rookie are height-adjustable. In addition to these classic functions of a task chair, other ergonomic features are directly incorporated into Rookie's structural design: the backrest flexes slightly when pressure is applied, and the front edge of the seat is unusually pliant; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Rookie; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-us/_storage/asset/2483518/storage/master/download/Factsheet%20Rookie%20Chair-EN.pdf; Type Name: Rookie; URL: https://www.vitra.com/en-us/office/product/details/rookie
Type - Materials and Finishes(Type) - OfficeChairTertiaryMaterial: Basic dark
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Chairs_Vitra_Rookie; Features: Height adjustable in accordance with EN 16139.; Finish: Backrest: back made of polypropylene and back cushion made of polyurethane foam. Back shell in soft grey or deep black; back cushion with fabric or leather cover stretched over padding. Backrest height adjustable up to 55 mm using a quick release lever. Seat: polypropylene shell in soft grey or deep black; polyurethane foam cushion; fabric or leather cover stretched over padding. Equipped as standard with seat height adjustment. Base: five-star base made of polyamide in soft grey or deep black; double castors (Ø 60 mm) in basic dark.; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Rookie; ReplacementCost: n/a; Shape: Sculptured; Size: 680x680x710-900 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - HeightControl: 710 mm; TotalHeight: 710 mm
Dimensions - Area: 1.5123 m2; NominalHeight: 710 mm; Volume: 0.357911 m3
Materials and Finishes - OfficeChairMainMaterial: Sierra grey 19; OfficeChairSecondaryMaterial: 53 soft grey
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Office-Chairs_Vitra_Rookie: Rookie; Family and Type: Furniture_Office-Chairs_Vitra_Rookie: Rookie; InstallationDate: n/a; Material: Polypropylene, polyurethane, polyamide, & textile or leather.; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Chairs_Vitra_Rookie: Rookie; Type Id: Furniture_Office-Chairs_Vitra_Rookie: Rookie; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
